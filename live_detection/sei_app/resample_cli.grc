options:
  parameters:
    author: user
    generate_options: no_gui
    id: resample_cli
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: bw
    gain: '1.0'
    samp_rate: samp_rate
    width: '1000000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: file_output
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'True'
    type: complex
  states: {}
- name: bw
  id: parameter
  parameters:
    type: eng_float
    value: '5000000'
  states: {}
- name: file_input
  id: parameter
  parameters:
    type: str
    value: '"filename.sigmf-data"'
  states: {}
- name: file_output
  id: parameter
  parameters:
    type: str
    value: '"filename_channelized.sigmf-data"'
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: offset_freq
    decim: '1'
    samp_rate: samp_rate
    taps: taps
  states: {}
- name: offset_freq
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: target_rate/samp_rate
    type: ccf
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: '40000000'
  states: {}
- name: target_rate
  id: parameter
  parameters:
    type: eng_float
    value: '10000000'
  states: {}

connections:
- [blocks_file_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', pfb_arb_resampler_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
